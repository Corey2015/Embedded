# IAR project D11.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\driver; ..\STM8S_StdPeriph_Driver\src; ..\STM8S_StdPeriph_Driver\inc; ..\user
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: D11.srec
  ILINK.IlinkOutputFile: D11.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group driver
    ../driver/: finger.c Key.c led.c uart.c
  group STM8S_StdPeriph_Driver
    ../STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_uart1.c
  group user
    ./: main.c stm8s_it.c
