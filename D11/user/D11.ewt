<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>driver</name>
    <file>
      <name>$PROJ_DIR$\..\driver\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driver\finger.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driver\key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driver\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driver\lockctr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driver\power.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driver\time.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driver\uart.c</name>
    </file>
  </group>
  <group>
    <name>STM8S_StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\STM8S_StdPeriph_Driver\src\stm8s_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8S_StdPeriph_Driver\src\stm8s_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8S_StdPeriph_Driver\src\stm8s_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8S_StdPeriph_Driver\src\stm8s_tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8S_StdPeriph_Driver\src\stm8s_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8S_StdPeriph_Driver\src\stm8s_tim4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8S_StdPeriph_Driver\src\stm8s_uart1.c</name>
    </file>
  </group>
  <group>
    <name>user</name>
    <file>
      <name>$PROJ_DIR$\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8s_it.c</name>
    </file>
  </group>
</project>


