<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\D11\user\D11.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\GPIO.ewp</path>
  </project>
  <batchBuild/>
</workspace>


